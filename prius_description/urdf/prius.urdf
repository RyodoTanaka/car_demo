Commit message: [update] add velodyne link

File: prius_description/urdf/prius.urdf (robot description, URDF)
Before this commit: robot prius, 24 links, 23 joints
Links:
- added link velodyne
Joints:
- added joint velodyne_joint: type fixed, parent center_laser_link, child velodyne
